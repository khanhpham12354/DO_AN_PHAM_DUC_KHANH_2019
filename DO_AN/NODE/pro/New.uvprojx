# Keil uVision project New.uvprojx, settings and files
target stm32l152c6 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Rhf76052 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32L1XX_MD
  c include: ..\inc\LIB\CMSIS\Device\ST\STM32L1xx\Include;..\inc\LIB\STM32L1xx_StdPeriph_Driver\inc;..\inc\LIB\CMSIS\Include;..\inc\user_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group library
    ../inc/LIB/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_rcc.c stm32l1xx_gpio.c stm32l1xx_usart.c misc.c stm32l1xx_syscfg.c stm32l1xx_rtc.c stm32l1xx_pwr.c stm32l1xx_exti.c stm32l1xx_adc.c
  group user
    ../src/: delay.c lora.c main.c usart.c init.c soil_moisture.c sht75.c pwr.c stm32_rtc.c kalman.c ph.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.0.0
